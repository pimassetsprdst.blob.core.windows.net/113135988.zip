Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Electrical_Sensors_ABB_Fusion-Smart.ifc
Time: 2022-04-07T09:24:43
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Fusion Smart
ePset_BIMobjectScript - Type: Fusion Smart Sensor-T; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Fusion Smart; SKU (BO_prodsku): FusionAirSeries; ManufacturName (BO_Manufac): ABB; BrandUrl (BO_brandurl): http://www.abb.com/; ProductFamily (BO_prodfam): Fusion Air Series; ProductGroup (BO_prodgroup): Sensor; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/abb/product/FusionAirSeries; ProductDataUrl (BO_prodaturl): bimobject.com/abb/product/FusionAirSeries; ProductUrl (BO_producturl): https://new.abb.com/low-voltage/products/building-automation/product-range/abb-cylon/products/visualization/abb-fusionair-smart-sensor; InstallationInstructions (BO_montins): https://library.e.abb.com/public/26f4871dbfcc4b23916aee0e6c1a9036/BDS0032_ABB%20FusionAir%20Smart%20Sensor.pdf?x-sign=WdQ6GBKXIcf+dKRHV/r5GHinRPTBquMYw7ujfPgAhtUYxYAT5sfMBiw/iRR+qNDV; TechnicalDescription (BO_techcert): https://library.e.abb.com/public/c546752cc1b04516a55b114f7d717209/DS0135_ABB_FusionAir_Smart_Sensor.pdf?x-sign=TrGfpxPCvZnNaHv7ACbHMRkD8WeY/oYzUSLHfdh7G3wXLeyUVgdyJnt/xovkeWRf; BimObjectMainCategory (BO_bomaincat): Electrical; BimObjectMainCategoryCode (BO_bomaincat_code): electrical; BimObjectCategory (BO_bocat): Sensors; BimObjectCategoryCode (BO_bocat_code): sensors; IfcClassification (BO_ifcclas): Electric Appliance; OmniClassCode (BO_omniclass_code): 23-27 11 11 23; OmniClassDescription (BO_omniclass_name): Temperature Sensors; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
